# Keil uVision project lesson.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: ..\qpn\include;..\ucos2\Source;..\ucos2\Ports\ARM-Cortex-M\ARMv7-M\ARM;.
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: main.c bsp.h bsp.c app_cfg.h os_cfg.h uc_ao.h uc_ao.c
  group StartUp
    ./: stm32f4_cmsis.h startup_stm32f1.c
  group ucos2
    ../ucos2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos2-port
    ../ucos2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_dbg.c os_cpu_a.asm os_cpu.h
    ../ucos2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
