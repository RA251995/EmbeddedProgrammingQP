# Keil uVision project lesson.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\qpn\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\lesson.sct
  group Application
    ./: main.c bsp.c bsp.h
  group MiROS
    ./: miros.c miros.h
  group StartUp
    ./: stm32f4_cmsis.h startup_stm32f1.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
