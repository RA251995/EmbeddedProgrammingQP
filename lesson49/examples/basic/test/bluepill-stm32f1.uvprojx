# Keil uVision project bluepill-stm32f1.uvprojx, settings and files
target dbg (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  AfterMake: fromelf --bin --output .\build_bluepill-stm32f1\test.bin .\build_bluepill-stm32f1\test.axf
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: .;..\src;..\..\..\et;..\..\..\3rd_party\bluepill-stm32f1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group src
    ../src/: sum.c sum.h
  group test
    ./: test.c bsp_bluepill-stm32f1.c
  group ET
    ../../../et/: et.c et.h
  group bluepill-stm32f1
    ../../../3rd_party/bluepill-stm32f1/: startup_stm32f1.c startup_stm32f10x_md.s system_stm32f10x.c
